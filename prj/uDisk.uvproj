# Keil uVision project uDisk.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1833 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A03FFFF) IROM2(0x1B000000-0x1B03FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uDisk +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: __LPC18XX__ CORE_M3,CORE_M3,DEBUG_ENABLE
  c misc: --gnu --c99
  c include: ..\applications\LPCUSBlib\lpcusblib_DualDeviceAudioMSC;..\software\LPCUSBLib\Drivers\USB;..\software\LPCUSBLib\Common;..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\software\lpc_core\lpc_ip;..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\software\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830;..\software\CMSIS\Include;..\software\lpc_core\lpc_board\board_common;..\software\filesystems\fatfs\src;..\software\filesystems\fatfslpc;..\applications\LPCUSBlib\lpcusblib_DualDeviceAudioMSC\my
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group start
    ../applications/lpc18xx/startup_code/: keil_startup_lpc18xx43xx.s
  group src
    ../applications/LPCUSBlib/lpcusblib_DualDeviceAudioMSC/: uDisk.c MassStorage.c MassStorageDescriptors.c MassStorageHost.c sdmmc.c
    ../applications/LPCUSBlib/lpcusblib_DualDeviceAudioMSC/Lib/: SCSI.c
    ../applications/LPCUSBlib/lpcusblib_DualDeviceAudioMSC/my/: param.c
  group BSP
    ../software/lpc_core/lpc_board/boards_18xx_43xx/ngx_xplorer_18304330/: board_ngx_xplorer_18304330.c sysinit_ngx_xplorer_18304330.c
  group fatfs
    ../software/filesystems/fatfs/src/: diskio.c ff.c
    ../software/filesystems/fatfslpc/: fs_mci.c fs_usb.c rtc.c
  group chip_ip
    ../software/lpc_core/lpc_ip/: adc_001.c atimer_001.c emc_001.c enet_001.c fpu_init.c gpdma_001.c gpioint_001.c gpiopinint_001.c i2c_001.c i2s_001.c lcd_001.c ritimer_001.c rtc_001.c sdmmc_001.c ssp_001.c timer_001.c usart_001.c wwdt_001.c sct_001.c ccan_001.c dac_001.c
  group chip_18xx
    ../software/lpc_core/lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c i2c_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pmc_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c scu_18xx_43xx.c sdmmc_18xx_43xx.c ssp_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
  group USB_Class
    ../software/LPCUSBLib/Drivers/USB/Class/Common/: HIDParser.c
    ../software/LPCUSBLib/Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ../software/LPCUSBLib/Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
  group USB_Core
    ../software/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group USB_HAL
    ../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group USB_HCD
    ../software/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../software/LPCUSBLib/Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
  group USB_DCD
    ../software/LPCUSBLib/Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../software/LPCUSBLib/Drivers/USB/Core/DCD/USBRom/: usbd_adcuser.c usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c
  group USB_Config
    ../software/LPCUSBLib/: LPCUSBlibConfig.h
